# Keil uVision project Project.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_MD
  c misc: --no-multibyte-chars
  c include: .\Start;.\User;.\Config;.\Bsp;.\Drivers;.\App
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Start
    ./Start/: startup_stm32f10x_md.s core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group User
    ./User/: main.c
  group Config
    ./Config/: car_config.h
  group Bsp
    ./Bsp/: bsp_gpio.c bsp_gpio.h bsp_time.c bsp_time.h bsp_usart.c bsp_usart.h
  group Drivers
    ./Drivers/: motor.c motor.h ultrasonic.c ultrasonic.h encoder.c encoder.h oled.c oled.h mpu6050.c mpu6050.h ir.c ir.h
  group App
    ./App/: app_car.c app_car.h
